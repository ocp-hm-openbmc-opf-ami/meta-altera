# Patches are applied via meta-altera/meta-common/recipes-phosphor/sensors/dbus-sensors_%.bbappend
# which covers both Agilex3 and Agilex5. Do not duplicate SRC_URI:append here.
