# oob-bios patch from meta-core does not apply to the AMI intel-ipmi-oem fork
SRC_URI:remove = "file://oob-bios/0001-fix-in-oob-bios.patch"
