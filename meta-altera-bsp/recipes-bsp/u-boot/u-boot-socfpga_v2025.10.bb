require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION ?= "v2025.10"
UBOOT_SRCREV ?= "dc4535b1e0593de7aafa5e70706c616ebebb64d6"

SRCREV = "${UBOOT_SRCREV}"
