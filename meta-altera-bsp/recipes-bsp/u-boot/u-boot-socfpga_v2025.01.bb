require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION ?= "v2025.01"
UBOOT_SRCREV ?= "ceee207f58e409c1405c2acbced29d285a50ac10"

SRCREV = "${UBOOT_SRCREV}"
