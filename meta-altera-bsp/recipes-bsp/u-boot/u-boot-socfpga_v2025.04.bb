require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION ?= "v2025.04"
UBOOT_SRCREV ?= "3dafe9b2cb85d73b8c1f42c65f20016922daf623"

SRCREV = "${UBOOT_SRCREV}"
