# Keep phosphor-ipmi-host enabled so libipmid is built and exported to dependent
# recipes (intel-ipmi-oem, phosphor-ipmi-blobs, etc.).
