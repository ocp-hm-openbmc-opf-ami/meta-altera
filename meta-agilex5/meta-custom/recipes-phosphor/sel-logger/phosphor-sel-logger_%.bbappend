DEPENDS:agilex5e_013b_openbmc += "intel-ipmi-oem"
RDEPENDS:${PN}:agilex5e_013b_openbmc += "intel-ipmi-oem"
RDEPENDS:${PN}:agilex5e_013b_openbmc:remove = "intel-ipmi-oem-ext"
